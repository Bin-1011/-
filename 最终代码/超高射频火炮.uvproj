# Keil uVision project 超高射频火炮.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 超高射频火炮 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED.c main.c delay.c LCD.c oled.c oled_show.c lcd_show.c sensor.c
  group Head
    ./: LED.h global.h delay.h LCD.h oled.h oledfont.h
